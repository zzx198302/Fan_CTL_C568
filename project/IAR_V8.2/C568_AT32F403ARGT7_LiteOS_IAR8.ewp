# IAR project C568_AT32F403ARGT7_LiteOS_IAR8.ewp, settings and files
configuration C568_AT32F403ARGT7_LiteOS_IAR8 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403ARGT7_v2 ArteryTek -AT32F403ARGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403ARGT7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm4\core_support; ..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\NewFile\LiteOS\arch\arm\arm-m\include; ..\..\NewFile\LiteOS\kernel\include; ..\..\NewFile\LiteOS\kernel\base\include; ..\..\NewFile\LiteOS\kernel\extended\include; ..\..\NewFile\LiteOS\OS_CONFIG; ..\..\NewFile\UserApp; ..\..\NewFile\UserDriver; ..\..\NewFile\Display; ..\..\middlewares\i2c_application_library
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: C568_AT32F403ARGT7_LiteOS_IAR8.hex
  ILINK.IlinkOutputFile: C568_AT32F403ARGT7_LiteOS_IAR8.out
  ILINK.IlinkIcfFile: AT32F403AxG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group middlewares
    ../../middlewares/i2c_application_library/: i2c_application.c
  group NewFile/Display
    ../../NewFile/Display/: aip1628_driver.c led_dsp.c
  group NewFile/LiteOS/Arch
    ../../NewFile/LiteOS/arch/arm/arm-m/cortex-m4/iar/: los_dispatch_iar.S
    ../../NewFile/LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group NewFile/LiteOS/Cmsis
    ../../NewFile/LiteOS/cmsis/: cmsis_liteos.c
  group NewFile/LiteOS/Kernel
    ../../NewFile/LiteOS/kernel/base/om/: los_err.c
    ../../NewFile/LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../NewFile/LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../NewFile/LiteOS/kernel/: los_init.c
    ../../NewFile/LiteOS/kernel/base/mem/membox/: los_membox.c
    ../../NewFile/LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../NewFile/LiteOS/kernel/base/misc/: los_misc.c
    ../../NewFile/LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../NewFile/LiteOS/kernel/extended/tickless/: los_tickless.c
  group NewFile/LiteOS/Os_Config
    ../../NewFile/LiteOS/OS_CONFIG/: los_builddef.h los_printf.h target_config.h
  group NewFile/UserApp
    ../../NewFile/UserApp/: UserAdc.c UserCommon.c UserEprom.c UserEventLog.c UserIO.c UserUsart1_(RS1).c UserUsart6_(RS2).c UserVariable.c
  group NewFile/UserDriver
    ../../NewFile/UserDriver/: Keyboard.c M24C64.c
  group user
    ../src/: at32f403a_407_int.c at32f403a_407_wk_config.c main.c rtc.c wk_adc.c wk_debug.c wk_dma.c wk_gpio.c wk_i2c.c wk_rtc.c wk_system.c wk_tmr.c wk_usart.c wk_wdt.c
