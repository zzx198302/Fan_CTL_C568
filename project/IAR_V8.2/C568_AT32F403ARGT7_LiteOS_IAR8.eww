<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\C568_AT32F403ARGT7_LiteOS_IAR8.ewp</path>
  </project>
  <batchBuild/>
</workspace>


